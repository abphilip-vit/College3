# Keil uVision project E5.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: E5
  c flags: Optimize=8 SizeSpeed=1
